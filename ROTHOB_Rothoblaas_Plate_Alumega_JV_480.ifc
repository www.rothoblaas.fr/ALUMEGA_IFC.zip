Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 6ad17a52-26d9-4283-ac4c-9db191c14263, NumberOfSaves: 47], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Plate_Alumega_JV_480.ifc
Time: 2025-08-26T08:27:41
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcMember: Collegamenti strutturali : ROTHOB_Rothoblaas_Plate_Alumega_JV_480 : 95x480x49mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: Red, ROTHOB_Rothoblaas_Aluminium
Type - Generale - Author: Vitor Ferronato; BIMObjectName: ROTHOB_Rothoblaas_Plate_Alumega_JV; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/concealed-connections/alumega#alumega; Revision: 1; UniClass2015Code: Pr_20_76_51_07; UniClass2015Title: Aluminium structural sections; UniClass2015Version: Products v1.30; Version: 1
Type - Vincoli - ModelNumberCode: 480; Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_Aluminium
Type - Quote - Depth_P: 49 mm; Height_H: 480 mm; WebLength_LB: 49 mm; WebThickness_s2: 6 mm; Width_B: 95 mm; WingThickness_s1: 8 mm; WingWidth_LA: 95 mm
Type - Dati identità - Nome del tipo: 95x480x49mm; Numero OmniClass: 23.13.23.11.19.13
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: n/a; Category: Pr_20_76_51_07: Aluminium structural sections; CodePerformance: Construction products; Color: Silver; Constituents: n/a; Description: Pinned connection for post and beam; DurationUnit: Years; ExpectedLife: n/a; Features: Bracket for timber-to-timber, timber-to-concrete, timber-to-steel joints; Finish: n/a; Grade: n/a; Manufacturer: info@rothoblaas.com; Material: Aluminium; MinWeight: 1.94 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: ALUMEGA480JV; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_Alumega_JV_480; NominalDepth: 49 mm; NominalHeight: 480 mm; NominalWidth: 95 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 95x480x49 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_76_51_07: Aluminium structural sections
Pset_MemberCommon - Reference: 95x480x49mm
Pset_QuantityTakeOff - Reference: 95x480x49mm
BaseQuantities - Length: 480 mm; CrossSectionArea: 0.00125227 m2; OuterSurfaceArea: 0.172878 m2; GrossSurfaceArea: 0.175383 m2; GrossVolume: 0.00060109 m3; NetVolume: 0.000534323 m3; NetSurfaceArea: 0.173833 m2
Vincoli - Host: Piano di riferimento : REF; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Strutturale - Copriferro armatura: Copriferro armatura 1 <25 mm>
Quote - Area: 0.0000899887 m2; Volume: 3.58446e-08 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_Alumega_JV_480; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_Alumega_JV_480: 95x480x49mm; ID tipo: 529656; Tipo: 95x480x49mm

# IfcOpeningElement: Opening (46)
In: 0_Rothoblaas
BaseQuantities - Depth: 480 mm; Area: 0.00125227 m2
Pset_OpeningElementCommon - Reference: 95x480x49mm; sets with these values: 2
Name (Collegamenti strutturali : ROTHOB_Rothoblaas_Plate_Alumega_JV_480 : 95x480x49mm:...)
1
2
3
4
5
6
7
8
9
10
11
12
13
14
15
16
17
18
19
20
21
22
23
24
25
26
27
28
29
30
31
32
33
34
35
36
37
38
39
40
41
42
43
44
45
46
