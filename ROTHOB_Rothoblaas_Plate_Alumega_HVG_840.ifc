Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView], RevitIdentifiers [VersionGUID: 6e285f6a-6f0e-40d7-8184-0dbc4fb3f918, NumberOfSaves: 44], CoordinateReference [CoordinateBase: Project Base Point, ProjectSite: Planimetria di default]
File name: ROTHOB_Rothoblaas_Plate_Alumega_HVG_840.ifc
Time: 2025-08-06T15:06:05
Written by: ODA IFC SDK 22.8
Made in: 22.1.80.32 - IFC 22.7.0.0 - Default UI

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 mm
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello, 0_Rothoblaas
LongName: 0_Rothoblaas; Elevation: 0 mm
Vincoli - Quota altimetrica: 0 mm
Quote - Altezza di calcolo: 0 mm
Dati identità - Nome: 0_Rothoblaas; Piano edificio: yes; Strutturale: no
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Type) - Nome del tipo: Livello
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello

# IfcMember: Collegamenti strutturali : ROTHOB_Rothoblaas_Plate_Alumega_HVG : HVG840_95x50x840mm
In: 0_Rothoblaas
Type - PredefinedType: USERDEFINED; Material: ROTHOB_Rothoblaas_Aluminium6082
Type - Generale - Author: Augusto Meorali; BIMObjectName: ROTHOB_Rothoblaas_Plate_Alumega_HVG; ManufacturerName: ROTHO BLAAS SRL; ManufacturerURL: www.rothoblaas.com; OmniClassCode: 23-13 23 11 19 13; OmniClassTitle: Wood Connectors; OmniClassVersion: 2012-05-16; ProductInformation: https://www.rothoblaas.com/products/fastening/brackets-and-plates/concealed-connections/alumega; Revision: 000; UniClass2015Code: Pr_20_76_51_07; UniClass2015Title: Aluminium structural sections; UniClass2015Version: Products v1.38; Version: 001
Type - Vincoli - ModelNumberCode: 840; Prospetto di default: 1219.2 mm
Type - Materiali e finiture - ObjectMaterial: ROTHOB_Rothoblaas_Aluminium6082
Type - Quote - Depth_P: 50 mm; Height_H: 840 mm; N°CircularHolesExtPerSide: 13; N°CircularHolesIntPerSide: 7; N°InclinedHolesPerSide: 14; N°WebHoles: 13; Width_B: 95 mm
Type - Dati identità - Descrizione: Pinned connection for post and beam; Nome del tipo: HVG840_95x50x840mm; Numero OmniClass: 23.13.23.11.19.13; Produttore: info@rothoblaas.com
Type - Altro - Categoria: Collegamenti strutturali; AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_20_76_51_07: Aluminium structural sections; CECode: ETA-23/0824; CETitle: Rotho Blaas ALUMEGA connectors; CodePerformance: CE - Construction products; Color: Silver; Constituents: n/a; Description: Pinned connection for post and beam; DurationUnit: Years; ExpectedLife: 50; Features: Concealed joint for beam in timber-to-timber configuration; Finish: n/a; Grade: n/a; GTIN: 8054045438481; Manufacturer: info@rothoblaas.com; Material: EN AW-6082 Aluminium alloy; MinWeight: 3.35 kg; ModelDisclaimer: The latest version of the data sheets can be found on our website; ModelNumber: ALUMEGA840HVG; ModelReference: n/a; Name: Plate; Nome famiglia: ROTHOB_Rothoblaas_Plate_Alumega_HVG; NominalDepth_P: 50 mm; NominalHeight: 840 mm; NominalWidth: 95 mm; ReplacementCost: n/a; Shape: Three-dimensional; Size: 95x50x840 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ElementShading - Color: Silver
Type - Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: info@rothoblaas.com
Type - Pset_MemberCommon - IsExternal: no
Type - Pset_ProductRequirements - Name: Plate; Category: Pr_20_76_51_07: Aluminium structural sections
Pset_MemberCommon - Reference: HVG840_95x50x840mm
Pset_QuantityTakeOff - Reference: HVG840_95x50x840mm
BaseQuantities - CrossSectionArea: 0.140225 m2; NetVolume: 0.00109597 m3; NetSurfaceArea: 0.28045 m2
Vincoli - Host: Piano di riferimento : REF; Quota altimetrica da livello: 0 mm
Fasi - Fase di creazione: Stato di Progetto
Quote - Area: 0.140225 m2; Volume: 0.00109597 m3
Altro - Famiglia: ROTHOB_Rothoblaas_Plate_Alumega_HVG; Famiglia e tipo: ROTHOB_Rothoblaas_Plate_Alumega_HVG: HVG840_95x50x840mm; ID tipo: 505291; Tipo: HVG840_95x50x840mm
